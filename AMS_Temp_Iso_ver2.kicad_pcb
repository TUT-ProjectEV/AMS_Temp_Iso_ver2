# Repository TUT-ProjectEV/AMS_Temp_Iso_ver2

File README.md:

# AMS_Temp_Iso_ver2

## Overview
- AMSの温度測定基板
- スレーブ側
- 2023年度10月時点で使用

## Requirement
### Development
- Kicad 7.0
### Boards
- Arduino UNO
- Arduino Pro Mini
### Libraries

## Usage
- Arduinoマイコンボードとして使用
- マイコン2つ乗り
- サーミスタ 6 x 2

## Features
- ブートローダ書き込みの際に、どの互換ボードとして動作するか指定可能

## Reference
- [AMS_Temp_Iso_ver2](https://github.com/ST04-tkmr/KicadProjects_EVProject/tree/main/AMS_Temp_Iso_ver2) より

## Author
- Takamura
    - [GitHub](https://github.com/ST04-tkmr)

## License
- Copyright (c) 2023 東京工科大学 ProjectEV [Released under the MIT license](https://github.com/TUT-ProjectEV/AMS_Temp_Iso_ver2/blob/main/LICENSE)

## KiCad design AMS_Temp_Iso_ver2.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C11, C12, C15: 0.1u; C_0603_1608Metric
C9, C10: 3.3u; CP_Radial_D5.0mm_P2.00mm
C13, C14: 1u; C_0603_1608Metric
D1, D2: LED; LED_0603_1608Metric
D3, D4: CUHS20S30; CUHS20S40H3F
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J13: Conn_01x10_Socket; PinSocket_1x10_P2.54mm_Vertical
J14, J15, J16, J17: Conn_01x04_Pin; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J18, J19: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
PS1: MCWI03-12S05; MCWI0312S15
R1, R2, R3, R4, R5, R6, R8, R9, R10, R11, R12, R13, R15: 10k; C_0805_2012Metric
R7, R14: Opt; R_0603_1608Metric
R16, R17, R18, R19: 3.3k; R_0603_1608Metric
U1, U2: ATmega328P-A; TQFP-32_7x7mm_P0.8mm
U3: ADuM1250; SOIC-8_3.9x4.9mm_P1.27mm
U4: NJM78L05SU3; SOT-89-3
Y1, Y2: CSTCE16M0V53-R0; CSTCE16M0V53R0; Manufacturer_Part_Number CSTCE16M0V53-R0; Mouser Part Number 81-CSTCE16M0V53-R0

Connections:
+5V: J13.3, J14.1, J18.2, J19.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R15.1
+5VA: C1.1, C2.1, C3.1, J19.1, R7.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC)
+5VD: C6.1, C7.1, C8.1, J18.1, R14.1, U2.4 (VCC), U2.6 (VCC), U2.18 (AVCC)
+5VL: C11.1, C14.1, D4.2 (A), R16.1, R17.1, U3.1 (VDD1), U4.1 (Vout)
+5VP: C10.1, C12.1, J17.4, PS1.6 (+Vout), R18.1, R19.1, U3.8 (VDD2)
+12V: C13.1, D3.2 (A), D4.1 (K), J15.1, J16.4, U4.3 (Vin)
/+Vin: C9.1, D3.1 (K), PS1.2 (+Vin)
/DTR: C15.2, J13.6
/SCL1: J15.3, J16.2, R17.2, U3.3 (SCL1)
/SCL2: J17.2, R19.2, U3.6 (SCL2)
/SDA1: J15.2, J16.3, R16.2, U3.2 (SDA1)
/SDA2: J17.3, R18.2, U3.7 (SDA2)
/Sens1: J1.1, R1.2, U1.23 (PC0)
/Sens2: J2.1, R2.2, U1.24 (PC1)
/Sens3: J3.1, R3.2, U1.25 (PC2)
/Sens4: J4.1, R4.2, U1.26 (PC3)
/Sens5: J5.1, R5.2, U1.19 (ADC6)
/Sens6: J6.1, R6.2, U1.22 (ADC7)
/Sens7: J7.1, R8.2, U2.23 (PC0)
/Sens8: J8.1, R9.2, U2.24 (PC1)
/Sens9: J9.1, R10.2, U2.25 (PC2)
/Sens10: J10.1, R11.2, U2.26 (PC3)
/Sens11: J11.1, R12.2, U2.19 (ADC6)
/Sens12: J12.1, R13.2, U2.22 (ADC7)
/XTAL1_A: U1.7 (XTAL1/PB6), Y1.3 (OUTPUT)
/XTAL1_D: U2.7 (XTAL1/PB6), Y2.3 (OUTPUT)
/XTAL2_A: U1.8 (XTAL2/PB7), Y1.1 (INPUT)
/XTAL2_D: U2.8 (XTAL2/PB7), Y2.1 (INPUT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.1 (K), D2.1 (K), J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, J12.2, J13.1, J13.2, J14.4, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.3 (GND), U2.5 (GND), U2.21 (GND), Y1.2 (GND), Y2.2 (GND)
GND1: C9.2, C11.2, C13.2, C14.2, J15.4, J16.1, PS1.1 (-Vin), PS1.3 (Remote_On/Off), U3.4 (GND1), U4.2 (GND)
GND2: C10.2, C12.2, J17.1, PS1.7 (-Vout), U3.5 (GND2)
MISO: J13.10, U1.16 (PB4), U2.16 (PB4)
MOSI: J13.9, U1.15 (PB3), U2.15 (PB3)
unnamed: D1.2 (A), R7.2
unnamed: D2.2 (A), R14.2
unnamed: C4.1, U1.20 (AREF)
unnamed: C5.1, U2.20 (AREF)
RESET: C15.1, J13.7, R15.2, U1.29 (~RESET/PC6), U2.29 (~RESET/PC6)
RXI: J13.4, U1.30 (PD0), U2.30 (PD0)
SCK: J13.8, U1.17 (PB5), U2.17 (PB5)
SCL: J14.3, U1.28 (PC5), U2.28 (PC5)
SDA: J14.2, U1.27 (PC4), U2.27 (PC4)
TXO: J13.5, U1.31 (PD1), U2.31 (PD1)

Notes on the sheet:
OUTPUT
上基板
ジャンパピンで短絡 書き込みのときは書き込むマイコン側のみ短絡
INPUT
下基板

Board: 2 copper layers, 85.0 x 117.5 mm, 64 parts (20 on the bottom side), 43 nets.

## Commit log

2023-10-22 add project
